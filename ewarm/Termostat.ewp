# IAR project Termostat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; STM32F030x6
  ICCARM.CCIncludePath2: ..\src; ..\src\app; ..\src\lib; ..\src\drivers; ..\src\system; ..\src\cmsis
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Termostat.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Termostat.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F030; STM32F030x6; USE_MINI_STD
  OBJCOPY.OOCOutputFile: H44780.hex
  group (top)
    ../src/: main.c
  group app
    ../src/app/: settings.c thermostat.c ui.c
  group drivers
    ../src/drivers/: board.c ds18b20.c flash.c HD44780.c
  group lib
    ../src/lib/: crc.c menu_system.c regulator.c
  group system
    ../src/system/: startup.c system_stm32f0xx.c
