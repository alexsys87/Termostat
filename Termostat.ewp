# IAR project Termostat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; STM32F030x6
  ICCARM.CCIncludePath2: ; CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Termostat.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Termostat.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F030; STM32F030x6; USE_MINI_STD
  ICCARM.CCIncludePath2: ; ..\BSP; ..\CMSIS; ..\EEPROM
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: H44780.hex
  group (top)
    ./: ds18b20.c flash_storage.c HD44780.c main.c menu_system.c startup.c system_stm32f0xx.c
